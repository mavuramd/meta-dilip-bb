KBRANCH_beaglebone-yocto = "v5.4/standard/beaglebone"

KMACHINE_beaglebone-yocto ?= "beaglebone"

SRCREV_machine_beaglebone-yocto ?= "122179cb7d648a6f36b20dd6bf34f953cb384c30"

COMPATIBLE_MACHINE_beaglebone-yocto = "beaglebone-yocto"

LINUX_VERSION_beaglebone-yocto = "5.4.7"
